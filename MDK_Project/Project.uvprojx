# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UAIR +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Lib\inc;..\Lib;..\User;..\User\word;..\User\word\device;..\User\word\int;..\User\word\md5;..\User\word\socket;..\User\word\spi;..\User\word\ult;..\User\word\w5500;..\User\word\dhcp;..\User\word\http;..\User\word\24c02
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Lib/ARM/: startup_stm32f10x_hd.s
  group Lib
    ../Lib/: core_cm3.c system_stm32f10x.c
    ../Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_iwdg.c
  group User
    ../User/: main.c stm32config.c stm32f10x_it.c delay.c Timer.c sim800c.c hcho.c net.c tool.c
  group readme
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
